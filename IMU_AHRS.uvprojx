# Keil uVision project IMU_AHRS.uvprojx, settings and files
target IMU_AHRS (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IMU_AHRS +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\StartUp;.\User_Src;.\Lib\inc;.\HardWareDriver;.\HardWareDriver\BMP085;.\HardWareDriver\HMC5883L;.\HardWareDriver\IMU;.\HardWareDriver\LED;.\HardWareDriver\MPU6050;.\HardWareDriver\UART2;.\HardWareDriver\UARTs;.\HardWareDriver\MS5611;.\HardWareDriver\TIMER;.\HardWareDriver\sys;.\HardWareDriver\KEY;.\HardWareDriver\delay;.\HardWareDriver\delaysys;.\HardWareDriver\TIME;.\HardWareDriver\SPI;.\HardWareDriver\NRF24L01;.\HardWareDriver\ADC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./StartUp/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group HardWareDriver
    ./HardWareDriver/: IOI2C.c
    ./HardWareDriver/UARTs/: UARTs.c
    ./HardWareDriver/TIMER/: timer.c
    ./HardWareDriver/sys/: sys.c
    ./HardWareDriver/KEY/: key.c
    ./HardWareDriver/LED/: led.c
    ./HardWareDriver/delay/: delay.c
    ./HardWareDriver/delaysys/: delaysys.c
    ./HardWareDriver/TIME/: time.c
    ./HardWareDriver/NRF24L01/: 24l01.c
    ./HardWareDriver/SPI/: spi.c
    ./HardWareDriver/ADC/: adc.c
  group User_Src
    ./User_Src/: main.c stm32f10x_it.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_adc.c
